Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: c44117c3-0652-480d-adc9-13fbb97828a1, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 146045.ifc
Time: 2026-02-17T12:10:17+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFlowTerminal: PF_ST_KlassikDrain_K300 & KS300_channels_AUS_ACO:KlassikDrain_K300_Invert_Depth_400mm to 449mm, PF_ST_KlassikDrain_K300 & KS300_channels_AUS_ACO:KlassikDrain_K300_Invert_Depth_400mm to 449mm:359129
In: Level 1
Type - Description: ACO KlassikDrain K300/KS300 channels; PredefinedType: USERDEFINED; Material: Steel, Galvanised, polymer concrete
Type - Other - Category: Plumbing Fixtures; Family Name: PF_ST_KlassikDrain_K300 & KS300_channels_AUS_ACO
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Dimensions - height_01: 0 mm
Type - Identity Data - Address: ACO Pty Ltd, Australia; Description: ACO KlassikDrain K300/KS300 channels; email-sales: sales@acoaus.com.au; email-Technical: sales@acoaus.com.au; LOD: LOD 300; Manufacturer: ACO; Model: KlassikDrain K300/KS300 channels; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1300 765 226; Type Comments: --; Type Name: KlassikDrain_K300_Invert_Depth_400mm to 449mm; URL: https://acodrain.com.au/
Type - Materials and Finishes - material_01_C_ANZRS: polymer concrete; material_C_ANZRS: Steel, Galvanised
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: KlassikDrain_K300_Invert_Depth_400mm to 449mm; sets with these values: 2
Other - calculated_min_length: 492.145 mm; cut_radius: 370 mm; Family: PF_ST_KlassikDrain_K300 & KS300_channels_AUS_ACO; Family and Type: PF_ST_KlassikDrain_K300 & KS300_channels_AUS_ACO: KlassikDrain_K300_Invert_Depth_400mm to 449mm; grating_position: 1500 mm; height_index: 0; left_gratecut_length: 994 mm; length_01_C_ANZRS: 1000 mm; length_02_C_ANZRS: 1000 mm; length_calculated: 1000 mm; Neutral_channel_0.5m_check: 0; Neutral_channel_1m_check: 1; right_gratecut_length: 2006 mm; Sloped_channel_check: 0; toggle_left_endcap: no; toggle_right_endcap: no; Type: KlassikDrain_K300_Invert_Depth_400mm to 449mm; Type Id: 359088; width_C_ANZRS: 350 mm
Constraints - 1000mm_grating: yes; 500mm_grating: no; angle_01_C_ANZRS: 0 deg; angle_02_C_ANZRS: 0 deg; channel_length_selection_warning ⚠️: ⚠️Channel length is restricted to a minimum of 500 mm and a maximum of 1000 mm; Elevation from Level: 0 mm; Grate removal tool: no; gratings: KlassikDrain_K300_gratings : Type 839D Stainless Splitwire Heelsafe® Anti-Slip grate (1m); Installation device: no; Invert_depth: 400 mm; Invert_depth_selection_warning ⚠️: --; length_C_ANZRS: 1000 mm; Level: Level 1; Neutral_channel_0.5m: no; Neutral_channel_1m: yes; Neutral_channel_selection_warning ⚠️: ⚠️Neutral channel is available for an Invert depth of 400mm; Offset from Host: 0 mm; QuickLok bar: no; Schedule Level: Level 1; Sloped_channel: no; Universal_end_cap_left: no; Universal_end_cap_right: no; Work Plane: Level : Level 1
Dimensions - actual_length: 1000 mm; angle_left_calculated: 0 deg; angle_max: 72 deg; angle_min: -72 deg; angle_right_calculated: 0 deg; Area: 1.15579 m2; calculated_Invert_depth_check: 400 mm; calculated_invert_depth_male: 400 mm; channel_overall_width: 360 mm; Diameter_01: 99 mm; Internal_channel_width: 300 mm; invert_depth_female: 400 mm; left_angle_max: 180 deg; left_angle_min: 0 deg; overall_depth_male: 425 mm; right_angle_max: -180 deg; right_angle_min: 0 deg; Volume: 0.0533301 m3
General - code_specification_URL_C_ANZRS: https://acodrain.com.au/products/klassikdrain-removable-grates/; content_creator_C_ANZRS: ACO Technology Centre, INDIA; content_date_changed_C_ANZRS: 01-02-2026; content_version_C_ANZRS: 1.0; info_commercial_C_ANZRS: https://acodrain.com.au/products/klassikdrain-removable-grates/; info_technical_C_ANZRS: https://acodrain.com.au/products/klassikdrain-removable-grates/; intended_use_C_ANZRS: https://acodrain.com.au/products/klassikdrain-removable-grates/
Identity Data - code_supplier_article_C_ANZRS: 146045; item_description: K3-020 Neutral channel - (1m); Mark: 1; productrange: KlassikDrain; Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems
Phasing - Phase Created: New Construction
Structural - net_mass_S_ANZRS: 70.5 kg
Text - lookup_table_name: KlassikDrain_K300

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K300_gratings_ACO:std(nested), ZZZ_do not use_PF_ST_KlassikDrain_K300_gratings_ACO:std(nested):359133
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K300; Material: Steel, Stainless
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_KlassikDrain_K300_gratings_ACO; lookup_table_name: gratings_K300
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Identity Data - Address: ACO Pty Ltd, Australia; Description: ACO Grating for KlassikDrain_K300; email-sales: sales@acoaus.com.au; email-Technical: sales@acoaus.com.au; LOD: LOD 300; Manufacturer: ACO; Model: Grating for KlassikDrain_K300; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1300 765 226; Type Comments: --; Type Name: std(nested); URL: https://acodrain.com.au/
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - angle_left_calculated: 0 deg; angle_right_calculated: 0 deg; angle1_over_length_left: 0 mm; angle1_over_length_right: 0 mm; angle2_over_length_left: 0 mm; angle2_over_length_right: 0 mm; Family: ZZZ_do not use_PF_ST_KlassikDrain_K300_gratings_ACO; Family and Type: ZZZ_do not use_PF_ST_KlassikDrain_K300_gratings_ACO: std(nested); Grate_visible: yes; IsCustom: no; length_01_C_ANZRS: 1000 mm; length_1000_check: no; length_500_check: no; length_calculated: 1000 mm; product_index: 7; Type: std(nested); type_index: 7; Type Id: 358888; visible: no; width_C_ANZRS: 338 mm
Constraints - angle_01_C_ANZRS: 0 deg; angle_02_C_ANZRS: 0 deg; Elevation from Level: 0 mm; Offset from Host: 0 mm; length_C_ANZRS: 1000 mm; Moves With Nearby Elements: no
Dimensions - angle_max: 90 deg; angle_min: -90 deg; Area: 0.383316 m2; D_L1: 250 mm; D_L2: 250 mm; D_R1: 1250 mm; D_R2: 1250 mm; insertion_point: 750 mm; U_L1: 250 mm; U_L2: 250 mm; U_R1: 1250 mm; U_R2: 1250 mm; Volume: 0.01014 m3; width_01_C_ANZRS: 338 mm
Identity Data - code_supplier_article_C_ANZRS: 142573; item_description: Type 839D Stainless Splitwire Heelsafe® Anti-Slip grate (1m); Mark: 5; productrange: KlassikDrain; Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems
Materials and Finishes - material_01_C_ANZRS: Steel, Galvanised; material_C_ANZRS: Steel, Stainless
Phasing - Phase Created: New Construction
Structural - net_mass_S_ANZRS: 15.1 kg
