Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 775c0b11-a4e7-49c6-97bf-c53dc0973835, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 141822.ifc
Time: 2026-02-17T14:22:00+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcDistributionPort (15)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_360850_1
OutPort_360850_2
OutPort_360850_3
OutPort_360850_4
OutPort_360850_5
OutPort_360850_6
OutPort_360850_7
OutPort_360850_8
OutPort_360850_9
OutPort_360850_10
OutPort_360850_11
OutPort_360850_12
OutPort_360850_13
OutPort_360850_14
OutPort_360850_15

# IfcFlowTerminal: KlassikDrain_K3-903 In-line pit (0.5m):K3-903S In-line pit (0.5m), KlassikDrain_K3-903 In-line pit (0.5m):K3-903S In-line pit (0.5m):360850
In: Level 1
Type - Description: ACO K3-903S In-line pit (0.5m); PredefinedType: USERDEFINED; Material: PE, Black, polymer concrete, Steel, Stainless
Type - Other - Category: Plumbing Fixtures; Family Name: KlassikDrain_K3-903 In-line pit (0.5m)
Type - Constraints - Default Elevation: 0 mm
Type - General - code_specification_URL_C_ANZRS: https://acodrain.com.au/products/; content_creator_C_ANZRS: ACO Technology Centre, INDIA; content_date_changed_C_ANZRS: 05-02-2026; content_version_C_ANZRS: 1.0; info_commercial_C_ANZRS: https://acodrain.com.au/products/; info_technical_C_ANZRS: https://acodrain.com.au/products/; installation_manual: https://acodrain.com.au/products/; instructions_for_use: https://acodrain.com.au/products/; intended_use_C_ANZRS: Drainage systems
Type - Identity Data - Address: ACO Pty Ltd, Australia; Description: ACO K3-903S In-line pit (0.5m); email sales: sales@acoaus.com.au; email Technical: sales@acoaus.com.au; Manufacturer: ACO; Model: In-line pit (0.5m); OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1300 765 226; Type Name: K3-903S In-line pit (0.5m); URL: https://acodrain.com.au/products/
Type - Materials and Finishes - material_01_C_ANZRS: polymer concrete; material_02_C_ANZRS: PE, Black; material_C_ANZRS: Steel, Stainless
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: K3-903S In-line pit (0.5m); sets with these values: 2
Other - DN_100_sanitary_check: no; DN_150_sanitary_check: yes; DN_sanitary: yes; Family: KlassikDrain_K3-903 In-line pit (0.5m); Family and Type: KlassikDrain_K3-903 In-line pit (0.5m): K3-903S In-line pit (0.5m); material_index: 1; OD_sanitary: no; outlet_DN100: no; outlet_DN150: yes; Plastic_Riser_cutting_size: 5; Type: K3-903S In-line pit (0.5m); Type Id: 360815
Constraints - Elevation from Level: 0 mm; gratings: KlassikDrain_K300_in-line-pit_gratings : Type 876D Iron Intercept Heelsafe® Anti-Slip grate (0.5m); Host: Level : Level 1; length_02_C_ANZRS: 500 mm; Level: Level 1; Offset from Host: 0 mm; plastic rubbish basket: yes; plastic rubbish basket_long: yes; Riser_Depth: 250 mm; Riser_Visibility: yes
Dimensions - Area: 1.54436 m2; cap thickness: 2 mm; channel_inside_width: 300 mm; diameter_01_C_ANZRS: 75 mm; diameter_P_c01_ANZRS: 100 mm; diameter_P_c02_ANZRS: 150 mm; diameter_P_c03_ANZRS: 200 mm; h1: 223 mm; h2: 225 mm; Inline_pit_channel_profile_depth: 527 mm; Inline_pit_channel_profile_inside_depth: 501 mm; overall_in-line_pit_height: 843 mm; r1: 0 mm; rail: 25 mm; Riser_Depth_calculated: 250 mm; Volume: 0.108293 m3; width_01_C_ANZRS: 350 mm; width_02_C_ANZRS: 100 mm; width_03_C_ANZRS: 340 mm; width_04_C_ANZRS: 350 mm
Identity Data - code_gtin_C_ANZRS: -; code_supplier_article_C_ANZRS: 141822; item_description: ACO K3-903S In-line pit (0.5m); Mark: 1; productrange: KlassikDrain
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Structural - net_mass_S_ANZRS: 39.9 kg

# IfcFlowTerminal: ZZZ_do not use_PF_ST_K300_in-line-pit__gratings_ACO:std(nested), ZZZ_do not use_PF_ST_K300_in-line-pit__gratings_ACO:std(nested):360855
In: Level 1
Type - Description: ACO Inline-pit Grating for KlassikDrain_K300; Material: Iron Galvanised
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_K300_in-line-pit__gratings_ACO; lookup_table_name: gratings_K300_in-line-pit
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Identity Data - Address: ACO Pty Ltd, Australia; Description: ACO Inline-pit Grating for KlassikDrain_K300; email-sales: sales@acoaus.com.au; email-Technical: sales@acoaus.com.au; LOD: LOD 300; Manufacturer: ACO; Model: Inline-pit Grating for KlassikDrain_K300; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1300 765 226; Type Comments: --; Type Name: std(nested); URL: https://acodrain.com.au/
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - Type: std(nested); angle_left_calculated: 0 deg; angle_right_calculated: 0 deg; angle1_over_length_left: 0 mm; angle1_over_length_right: 0 mm; angle2_over_length_left: 0 mm; angle2_over_length_right: 0 mm; Brickslot_visible: yes; Family: ZZZ_do not use_PF_ST_K300_in-line-pit__gratings_ACO; Family and Type: ZZZ_do not use_PF_ST_K300_in-line-pit__gratings_ACO: std(nested); Grate_visible: yes; IsCustom: no; length_01_C_ANZRS: 500 mm; length_1000_check: no; length_500_check: no; length_calculated: 500 mm; product_index: 8; type_index: 8; Type Id: 360599; visible: no; width_C_ANZRS: 338 mm
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Moves With Nearby Elements: no; angle_01_C_ANZRS: 0 deg; angle_02_C_ANZRS: 0 deg; Host: Level : Level 1; length_C_ANZRS: 500 mm
Dimensions - angle_max: 90 deg; angle_min: -90 deg; Area: 0.199316 m2; D_L1: 500 mm; D_L2: 500 mm; D_R1: 1000 mm; D_R2: 1000 mm; insertion_point: 750 mm; U_L1: 500 mm; U_L2: 500 mm; U_R1: 1000 mm; U_R2: 1000 mm; Volume: 0.00507 m3; width_01_C_ANZRS: 338 mm
Identity Data - code_supplier_article_C_ANZRS: 142175; item_description: Type 876D Iron Intercept Heelsafe® Anti-Slip grate (0.5m); Mark: 6; productrange: KlassikDrain; Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems
Materials and Finishes - material_01_C_ANZRS: Steel, Galvanised; material_C_ANZRS: Iron Galvanised
Phasing - Phase Created: New Construction
Structural - net_mass_S_ANZRS: 15.9 kg

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K300_plastic_riser:std(nested) (5)
In: Level 1
Type - Description: Optional plastic riser; Material: PE, Black
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_KlassikDrain_K300_plastic_riser
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Dimensions - riser_bottom_thickness: 10 mm
Type - General - code_specification_URL_C_ANZRS: https://acodrain.com.au/products/; content_creator_C_ANZRS: ACO Technology Centre, INDIA; content_date_changed_C_ANZRS: 05-02-2025; content_version_C_ANZRS: 1.0; info_commercial_C_ANZRS: https://acodrain.com.au/products/; info_technical_C_ANZRS: https://acodrain.com.au/products/; installation_manual: https://acodrain.com.au/products/; instructions_for_use: https://acodrain.com.au/products/; intended_use_C_ANZRS: Drainage systems
Type - Identity Data - Address: ACO Pty Ltd, Australia; Description: Optional plastic riser; email sales: sales@acoaus.com.au; email Technical: sales@acoaus.com.au; Manufacturer: ACO; Model: Optional plastic riser; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1300 765 226; Type Name: std(nested); URL: www.acodrain.com.au
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - Family: ZZZ_do not use_PF_ST_KlassikDrain_K300_plastic_riser; Family and Type: ZZZ_do not use_PF_ST_KlassikDrain_K300_plastic_riser: std(nested); Riser_visibility: yes; Type: std(nested); Type Id: 360663
Constraints - Level: Level 1; Host: Level : Level 1; length_02_C_ANZRS: 490 mm; Moves With Nearby Elements: no
Dimensions - Area: 0.21809 m2; rail: 25 mm; Riser_depth: 43 mm; Volume: 0.0101718 m3; width_01_C_ANZRS: 340 mm
Identity Data - code_supplier_article_C_ANZRS: 141729; item_description: Optional plastic riser; productrange: KlassikDrain
Materials and Finishes - material_C_ANZRS: PE, Black
Phasing - Phase Created: New Construction
Structural - net_mass_S_ANZRS: 4.5 kg
Name (ZZZ_do not use_PF_ST_KlassikDrain_K300_plastic_riser:std(nested):...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
360851 | -653 | 2
360852 | -590 | 3
360853 | -527 | 4
361112 | -716 | 8
361113 | -653 | 9
