Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 775c0b11-a4e7-49c6-97bf-c53dc0973835, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 96826.ifc
Time: 2026-02-17T14:24:57+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K300_endcaps_ACO:std(nested), ZZZ_do not use_PF_ST_KlassikDrain_K300_endcaps_ACO:std(nested):362320
In: Level 1
Type - Description: ACO KlassikDrain K300 / KS300 Endcaps; PredefinedType: USERDEFINED; Material: grey ABS
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_KlassikDrain_K300_endcaps_ACO
Type - Constraints - Default Elevation: 0.0131234 mm
Type - General - code_specification_URL_C_ANZRS: https://acodrain.com.au/products/klassikdrain-removable-grates/#details; content_creator_C_ANZRS: ACO Technology Centre, INDIA; content_date_changed_C_ANZRS: 25-11-2025; content_version_C_ANZRS: 1.0; info_commercial_C_ANZRS: https://acodrain.com.au/products/klassikdrain-removable-grates/#details; info_technical_C_ANZRS: https://acodrain.com.au/products/klassikdrain-removable-grates/#details; installation_manual: https://acodrain.com.au/products/klassikdrain-removable-grates/#details; instructions_for_use: https://acodrain.com.au/products/klassikdrain-removable-grates/#details; intended_use_C_ANZRS: Drainage systems
Type - Identity Data - Address: ACO Pty Ltd, Australia; Description: ACO KlassikDrain K300 / KS300 Endcaps; email sales: sales@acoaus.com.au; email Technical: sales@acoaus.com.au; LOD: LOD 300; Manufacturer: ACO; Model: KlassikDrain K300 / KS300 Endcaps; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1300 765 226; Type Name: std(nested); Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems; URL: https://acodrain.com.au
Type - Materials and Finishes - material_01_C_ANZRS: grey ABS
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - Family: ZZZ_do not use_PF_ST_KlassikDrain_K300_endcaps_ACO; Family and Type: ZZZ_do not use_PF_ST_KlassikDrain_K300_endcaps_ACO: std(nested); Type: std(nested); Type Id: 362294; Visible: yes
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 0.164515 m2; height_C_ANZRS: 400 mm; Volume: 0.000803821 m3; width_01_C_ANZRS: 350 mm
Identity Data - code_gtin_C_ANZRS: -; code_supplier_article_C_ANZRS: 96826; item_description: K300/KS300 End cap; Mark: 1; productrange: KlassikDrain
Phasing - Phase Created: New Construction
Structural - net_mass_S_ANZRS: 1.1 kg
